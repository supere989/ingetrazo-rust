Properties of the parts of a building model (IFC4)

# File
File name: IfcBeam-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcBeam, Muro de José IfcBeam
In: Storey
Qto_BeamBaseQuantities - Length: 4 m; CrossSectionArea: 6 m2; GrossVolume: 24 m3
