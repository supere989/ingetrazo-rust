Properties of the parts of a building model (IFC4)

# File
File name: IfcCovering-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcCovering, Muro de José IfcCovering
In: Storey
Qto_CoveringBaseQuantities - GrossArea: 52 m2; NetArea: 52 m2
