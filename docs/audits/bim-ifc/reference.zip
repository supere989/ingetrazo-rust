Properties of the parts of a building model (IFC4)

# File
File name: IfcMember-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcMember, Muro de José IfcMember
In: Storey
Qto_MemberBaseQuantities - Length: 4 m; GrossVolume: 24 m3
