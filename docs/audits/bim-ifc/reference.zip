Properties of the parts of a building model (IFC4)

# File
File name: IfcWindow-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcWindow, Muro de José IfcWindow
In: Storey
OverallHeight: 4 m; OverallWidth: 3 m
Qto_WindowBaseQuantities - Width: 3 m; Height: 4 m; Area: 12 m2
