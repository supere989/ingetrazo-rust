Properties of the parts of a building model (IFC4)

# File
File name: IfcPile-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcPile, Muro de José IfcPile
In: Storey
Qto_PileBaseQuantities - Length: 4 m; GrossVolume: 24 m3
