Properties of the parts of a building model (IFC4)

# File
File name: IfcRoof-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcRoof, Muro de José IfcRoof
In: Storey
Qto_RoofBaseQuantities - Length: 3 m; GrossArea: 6 m2; GrossVolume: 24 m3
