Properties of the parts of a building model (IFC4)

# File
File name: rotated-door-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcDoor, Rotated
In: Storey
OverallHeight: 2 m; OverallWidth: 5 m
Qto_DoorBaseQuantities - Width: 5 m; Height: 2 m; Area: 10 m2
