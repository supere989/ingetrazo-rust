Properties of the parts of a building model (IFC4)

# File
File name: IfcSpace-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcSpace, Muro de José IfcSpace
LongName: IngeTrazo
Qto_SpaceBaseQuantities - Height: 4 m; NetFloorArea: 6 m2; GrossVolume: 24 m3
