Properties of the parts of a building model (IFC4)

# File
File name: unknown-class-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcBuildingElementProxy, Fallback
In: Storey
BaseQuantities - GrossArea: 52 m2; GrossVolume: 24 m3
