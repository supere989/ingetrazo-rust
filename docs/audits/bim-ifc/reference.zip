Properties of the parts of a building model (IFC4)

# File
File name: IfcFooting-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcFooting, Muro de José IfcFooting
In: Storey
Qto_FootingBaseQuantities - Height: 4 m; GrossSurfaceArea: 52 m2; GrossVolume: 24 m3
