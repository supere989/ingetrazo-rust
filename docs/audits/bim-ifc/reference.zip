Properties of the parts of a building model (IFC4)

# File
File name: IfcRailing-source.ifc
Time: 2026-10-11T04:30:31
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo
Made in: IngeTrazo

# IfcBuildingStorey, Storey
In: Building
Elevation: 0 m

# IfcRailing, Muro de José IfcRailing
In: Storey
Qto_RailingBaseQuantities - Length: 3 m; GrossVolume: 24 m3
