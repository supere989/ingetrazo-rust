Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcWindow, Muro de José IfcWindow
In: Storey 1
OverallHeight: 4 m; OverallWidth: 3 m
Qto_WindowBaseQuantities - Width: 3 m; Height: 4 m; Area: 12 m2
