Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcRamp, Muro de José IfcRamp
In: Storey 1
Qto_RampBaseQuantities - Length: 3 m; GrossArea: 6 m2; GrossVolume: 24 m3
