Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcColumn, Nested hidden
In: Storey 1
Qto_ColumnBaseQuantities - Length: 16 m; CrossSectionArea: 72 m2; GrossVolume: 1152 m3
