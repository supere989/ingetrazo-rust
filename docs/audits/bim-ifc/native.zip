Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcBuildingElementProxy, Fallback
In: Storey 1
BaseQuantities - GrossArea: 52 m2; GrossVolume: 24 m3
