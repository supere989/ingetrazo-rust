Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcDoor, Rotated
In: Storey 1
OverallHeight: 2 m; OverallWidth: 5 m
Qto_DoorBaseQuantities - Width: 5 m; Height: 2 m; Area: 10 m2
