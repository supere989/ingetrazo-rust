Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcBeam, Muro de José IfcBeam
In: Storey 1
Qto_BeamBaseQuantities - Length: 4 m; CrossSectionArea: 6 m2; GrossVolume: 24 m3
