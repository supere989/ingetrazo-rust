Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcSpace, Muro de José IfcSpace
In: Storey 1
LongName: IngeTrazo
Qto_SpaceBaseQuantities - Height: 4 m; NetFloorArea: 6 m2; GrossVolume: 24 m3
