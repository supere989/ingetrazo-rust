Properties of the parts of a building model (IFC4)

# File
File name: José's Project
Author: IngeTrazo
Organization: IngeTrazo
Written by: IngeTrazo Rust
Made in: IngeTrazo

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcCovering, Muro de José IfcCovering
In: Storey 1
Qto_CoveringBaseQuantities - GrossArea: 52 m2; NetArea: 52 m2
